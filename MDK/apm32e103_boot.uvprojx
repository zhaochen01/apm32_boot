# Keil uVision project apm32e103_boot.uvprojx, settings and files
target APM32E103_BOOT (6240000::V6.24::ARMCLANG)
  device: APM32E103RE Geehy
  pack: Geehy.APM32E1xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08003000,0x00006000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: apm32e103_boot
  AfterMake: fromelf --bin -o "$L..\..\out\@L.bin" "#L"
  AfterMake: python "$L..\..\tools\postbuild_boot_slot.py" "$L..\..\out\@L.bin" "$L..\..\out\@L"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: APM32E103_MINI
  c include: ..\Include;..\Lib\APM32E10x_StdPeriphDriver\inc;..\Lib\CMSIS\Include;..\Lib\Device\Geehy\APM32E10x\Include;..\App;..\Hw
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x1f800
  memory RVCT10: RAM 0x2001f800 size 0x800
  scatter file: .\apm32e103_boot.sct
  group App
    ../Source/: apm32e10x_int.c main.c
    ../App/: iap.c bsp_delay.c at_transport.c at_file_ops.c lte_modem.c upgrade_ctrl.c ram_flash.c serial_dl.c
    ./Listings/: apm32e103_boot.map
  group Hw
    ../Hw/: hw_uart.c hw_flash.c hw_uart3.c
  group StdPeriphDriver
    ../Lib/APM32E10x_StdPeriphDriver/src/: apm32e10x_bakpr.c apm32e10x_dma.c apm32e10x_gpio.c apm32e10x_misc.c apm32e10x_pmu.c apm32e10x_rcm.c apm32e10x_tmr.c apm32e10x_usart.c
  group CMSIS
    ../Source/: system_apm32e10x.c
    ../Lib/Device/Geehy/APM32E10x/Source/gcc/: gcc_APM32E10xxE.ld
    ../Lib/Device/Geehy/APM32E10x/Source/arm/: startup_apm32e10x_hd.s
